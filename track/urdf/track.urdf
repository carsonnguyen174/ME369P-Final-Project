Commit message: updates

File: track/urdf/track.urdf (robot description, URDF)
Before this commit: robot track, 1 links, 0 joints
Links:
- link base_link: mass 122116.506904259 -> 0.00606225780461374
